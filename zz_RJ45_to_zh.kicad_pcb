# Repository zinziroge/micro_Rack_RJ45_zh

## KiCad design zz_RJ45_to_zh.kicad_pcb

Parts:
C1, C2: 0.1uF; C_0603_1608Metric
C4: CL31B102KJHNNNE; CAPC3216X180N; Manufacturer_Part_Number CL31B102KJHNNNE; Mouser Part Number 187-CL31B102KJHNNNE
J1: Conn_02x03_Top_Bottom; PinSocket_2x03_P2.54mm_Horizontal
J2: RJMG1S8008101BR; AMPHENOL_RJMG1S8008101BR; PARTREV A

Connections:
ETH_RX1N: J1.4, J2.8 (RD-)
ETH_RX1P: J1.3, J2.7 (RD+)
ETH_TX1N: J1.2, J2.2 (TD-)
ETH_TX1P: J1.1, J2.1 (TD+)
GND: C1.2, C2.2, C4.1, J1.5, J1.6
GNDS: C4.2, J2.S1 (SHIELD), J2.S2 (SHIELD__1)
unnamed: C2.1, J2.3 (TCT1)
unnamed: C1.1, J2.6 (TCT2)

Notes on the sheet:
理想的にはnetwork機器側に置くが、 TCMT,RCMT,GNDをpinにだすと 信号線が増えてしまうので また、このCは共有できない
chassis GND
6:GND 5:CMT 4:RX1- 3:RX1+ 2:TX1- 1:TX1+
H1102 回路図
Pulse Transmitterを含むRJ45 connector

Board: 2 copper layers, 31.0 x 55.0 mm, 5 parts (0 on the bottom side), 8 nets.

File production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2",0603,2,0.1uF,
C4,CAPC3216X180N,1,CL31B102KJHNNNE,
J1,PinSocket_2x03_P2.54mm_Horizontal,1,Conn_02x03_Top_Bottom,
J2,AMPHENOL_RJMG1S8008101BR,1,RJMG1S8008101BR,

## Commit log

2025-11-01 modify
